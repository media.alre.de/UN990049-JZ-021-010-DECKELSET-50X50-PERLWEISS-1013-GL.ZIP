Properties of the parts of a building model (IFC2X3)

# File
Description: Deckelset für Raumhygrostat FHY, 50 x 50, perlweiß (RAL1013), glänzend, ViewDefinition[CoordinationView]
File name: ifc-2x3.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: UN990049, Deckelset für Raumhygrostat FHY, 50 x 50, perlweiß (RAL1013), glänzend
In: Raum
Description: Die Unterputzgeräte von alre passen in Verbindung mit dem entsprechenden Deckelset (Abdeckung) und Zwischenrahmen in alle gängigen Schalterprogramme. Durch das Baukastenprinzip (alre Basisgerät + alre Deckelset 50 x 50 mm + Zwischenrahmen vom Schalterhersteller + Rahmen vom Schalterhersteller) und diverse Farben (RAL 9010 reinweiß glanz/matt, RAL 1013 cremeweiß glanz, RAL 9016 verkehrsweiß glanz/matt) ist eine optisch perfekte Integration in Ihr favorisiertes Schalterprogramm möglich.; Classification: EC000011 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: UN990049; ModelLabel: JZ-021.010; GlobalTradeItemNumber: 4050528062284; ProductURL: https://alre.de/produkt_UN990049
Pset_Specification - NominalLength: 0.05 m; NominalWidth: 0.05 m; NominalDepth: 0.011 m; NetWeight: 0.011
Pset_ALRE_ETIM_Properties - Farbe: weiß; Breite: 50; Ausführung: Zentralplatte; Halogenfrei: yes; Höhe: 50; Tiefe: 11; Verwendung: sonstige; Oberflächenschutz: unbehandelt; Werkstoffgüte: Thermoplast; Werkstoff: Kunststoff; Befestigungsart: Schraubbefestigung; Aufdruck/Kennzeichnung: sonstige; Kontrollfenster/Lichtauslass: no; RAL-Nummer (ähnlich): 1013; Mit Beschriftungsfeld: no; Mit austauschbarer Linse/Symbol: no; Ausführung der Oberfläche: glänzend; Geeignet für Schutzart (IP): IP30; Geeignet für Bussystem-Tasterankopplung: no; Abtastbares Symbol/barrierefrei: no; ETIM-Klasse: EC000011; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-UN990049.pdf
